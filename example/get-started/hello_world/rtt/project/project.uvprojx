# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-GNU)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: main
  group Kernel
    ../../../../../rtos/rtthread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    ../../../../../customer/boards/common/: bsp_common.c bsp_psram.c flash.c
    ../../../../../customer/boards/sf32lb57-dpi-hdk_base/: bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c
    ../../../../../customer/peripherals/display/htm_h070a20/: htm_h070a20.c
    ../../../../../customer/peripherals/pa/AW8155/: sifli_aw8155.c
    ../../../../../customer/peripherals/touch_panel/gt911/: gt911.c
    ../../../../../rtos/rtthread/bsp/sifli/drivers/: drv_dma.c drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm_tim.c drv_pwm_lptim.c drv_pwm.c drv_spi.c drv_soft_i2c.c drv_i2c.c drv_adc.c drv_spi_flash.c drv_spi_nand.c drv_sys_cfg.c drv_rtc.c drv_audprc.c drv_audcodec_m.c drv_lcd_private.c drv_lcd.c drv_ram_lcd.c drv_lcd_test.c drv_lcd_fb.c drv_touch.c drv_epic.c drv_epic_single.c drv_psram.c drv_mpi.c drv_aes.c drv_common.c drv_dbg.c drv_epictl.c
  group CMSIS_BF0
    ../../../../../drivers/cmsis/sf32lb57x/: bf0_pin_const.c lcpu_config_type.c pmu_ldo_update.c lcpu_patch.c bf0_lcpu_init.c bt_rf_cw_config.c bt_power_config.c bt_rf_fulcal.c bt_rf_test.c bt_afh_test.c
    ../../../../../drivers/cmsis/sf32lb57x/Templates/: system_bf0_ap.c
    ../../../../../drivers/cmsis/sf32lb57x/Templates/gcc/: startup_bf0_hcpu.S
  group BF0_HAL
    ../../../../../drivers/hal/: bf0_hal.c bf0_hal_adc.c bf0_hal_aes.c bf0_hal_aes_ns.c bf0_hal_audcodec_m.c bf0_hal_audprc.c bf0_hal_bleaon.c bf0_hal_busmon.c bf0_hal_can.c bf0_hal_cortex.c bf0_hal_crc.c bf0_hal_dcmi.c bf0_hal_dma.c bf0_hal_dsi.c bf0_hal_efuse.c bf0_hal_epic.c bf0_hal_epictl.c bf0_hal_ext_dma.c bf0_hal_ezip.c bf0_hal_facc.c bf0_hal_fft.c bf0_hal_gpio.c bf0_hal_hcd.c bf0_hal_hlp.c bf0_hal_hpaon.c bf0_hal_hpaon_sf32lb57x.c bf0_hal_i2c.c bf0_hal_i2s.c bf0_hal_jpegd.c bf0_hal_lcdc.c bf0_hal_lcdc_aux.c bf0_hal_lcpu_config.c bf0_hal_lpaon.c bf0_hal_lpaon_sf32lb57x.c bf0_hal_lpcomp.c bf0_hal_lptim.c bf0_hal_lrc_cal.c bf0_hal_mailbox.c bf0_hal_mpi.c bf0_hal_mpi_ex.c bf0_hal_mpi_psram.c bf0_hal_nn_acc.c bf0_hal_patch.c bf0_hal_pcd.c bf0_hal_pdm.c bf0_hal_pinmux.c bf0_hal_pinmux_sf32lb57x.c bf0_hal_pmu.c bf0_hal_pmu_sf32lb57x.c bf0_hal_psram.c bf0_hal_ptc.c bf0_hal_pwm.c bf0_hal_rcc.c bf0_hal_rng.c bf0_hal_rtc.c bf0_hal_sd_ex.c bf0_hal_sdadc.c bf0_hal_sdhci.c bf0_hal_sdmmc.c bf0_hal_secu.c bf0_hal_spi.c bf0_hal_tim.c bf0_hal_tim_ex.c bf0_hal_tsen.c bf0_hal_uart.c bf0_hal_wdt.c bf0_sys_cfg.c bf0_sys_cfg_common.c bf0_sys_cfg_sf32lb57x.c flash_table.c nand_table.c sifli_bbm.c
  group lib_hal_epic_ex
    ./: hal_epic_ex_gcc
  group FlashDB
    ../../../../../external/FlashDB/port/fal/src/: fal.c fal_flash.c fal_flash_sifli_port.c fal_partition.c fal_rtt.c
  group google_lc3
    ../../../../../external/liblc3/src/: attdet.c bits.c bwdet.c energy.c lc3.c ltpf.c mdct.c plc.c sns.c spec.c tables.c tns.c
  group mbedtls
    ../../../../../external/mbedtls_228/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../../external/mbedtls_228/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_client_fallback.c tls_hardware.c tls_net.c
  group middleware
    ../../../../../middleware/sifli_matrix/: sifli_matrix.c
  group m_system
    ../../../../../middleware/system/: bf0_common.c
  group os_adapter
    ../../../../../rtos/os_adaptor/src/: os_adaptor_rtthread.c
  group Applications
    ../src/: main.c
  group CORTEX-M33
    ../../../../../rtos/rtthread/libcpu/arm/cortex-m33/: cpuport.c context_gcc.S
    ../../../../../rtos/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group CPlusPlus
    ../../../../../rtos/rtthread/components/cplusplus/: cxx_crt.cpp cxx_mutex.cpp cxx_semaphore.cpp cxx_thread.cpp cxx_crt_init.c
  group Filesystem
    ../../../../../rtos/rtthread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../../../rtos/rtthread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../../../../rtos/rtthread/components/drivers/audio/: audio.c audio_pipe.c
    ../../../../../rtos/rtthread/components/drivers/hwtimer/: hwtimer.c
    ../../../../../rtos/rtthread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../../../rtos/rtthread/components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../../../rtos/rtthread/components/drivers/mtd/: mtd_nor.c
    ../../../../../rtos/rtthread/components/drivers/rtc/: rtc.c
    ../../../../../rtos/rtthread/components/drivers/serial/: serial.c
    ../../../../../rtos/rtthread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../../../rtos/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c ringbuffer32.c waitqueue.c workqueue.c
  group finsh
    ../../../../../rtos/rtthread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../../../rtos/rtthread/components/libc/compilers/common/: gmtime_r.c unistd.c
  group newlib
    ../../../../../rtos/rtthread/components/libc/compilers/newlib/: libc.c libc_syms.c stdio.c syscalls.c time.c
  group newlib
    ./: c m
  group lwIP
    ../../../../../rtos/rtthread/components/net/lwip/lwip-2.1.2/src/core/: init.c def.c dns.c inet_chksum.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
    ../../../../../rtos/rtthread/components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../rtos/rtthread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../../../rtos/rtthread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../../../../rtos/rtthread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../../../rtos/rtthread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group Utilities
    ../../../../../rtos/rtthread/components/utilities/llt_mem/: llt_mem.c
